CMDLINE_RNDIS = "modules-load=dwc2,g_ether"
