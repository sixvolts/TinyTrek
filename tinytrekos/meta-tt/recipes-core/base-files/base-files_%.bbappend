hostname = "tinytrek"