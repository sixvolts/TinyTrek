FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://can_config.cfg"