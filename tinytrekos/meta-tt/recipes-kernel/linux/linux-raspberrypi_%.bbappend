RPI_KERNEL_DEVICETREE_OVERLAYS:append = " overlays/mcp2515.dtbo overlays/spi1-3cs.dtbo"
